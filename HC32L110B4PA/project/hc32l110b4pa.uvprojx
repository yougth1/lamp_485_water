# Keil uVision project hc32l110b4pa.uvprojx, settings and files
target hc32l110b4pa (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: HC32L110B4PA HDSC
  pack: HDSC.HC32L110.1.0.3
  cpu: IRAM(0x20000000,0x800) IROM(0x00000000,0x4000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: hc32l110b4pa +hex
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: ..\user;..\system
  memory RVCT4: ROM 0x0 size 0x4000
  memory RVCT9: RAM 0x20000000 size 0x800
  group app
    ../user/: adc.c bt.c clk.c ddl.c gpio.c uart.c main.c
  group system
    ../system/: startup_hc32l110b4pa.s interrupts_hc32l110.c system_hc32l110b4pa.c
